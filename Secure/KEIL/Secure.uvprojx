# Keil uVision project Secure.uvprojx, settings and files
target Secure (6220000::V6.22::ARMCLANG)
  device: M2354KJFAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x40000) IRAM2(0x30000000,0x40000) IROM(0x00000000,0x100000) IROM2(0x10000000,0x100000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: Secure
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=5
  c define: DEBUG_PORT = UART0_NS
  c misc: -mfloat-abi=soft -Wno-documentation -Wno-reserved-id-macro
  c include: ..\..\Secure;..\..\BSP_Library\CMSIS\Include;..\..\BSP_Library\Device\Nuvoton\M2354\Include;..\..\BSP_Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\secure.sct
  link misc: --import-cmse-lib-out ..\lib\nsclib.o
  group User
    ../: main.c partition_M2354.h
  group CMSIS
    ../../BSP_Library/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../../BSP_Library/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.s
  group Library
    ../../BSP_Library/StdDriver/src/: retarget.c clk.c gpio.c
